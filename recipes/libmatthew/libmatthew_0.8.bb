require libmatthew.inc

PR = "r1"

SRC_URI = "http://www.matthew.ath.cx/projects/java/libmatthew-java-${PV}.tar.gz \
           file://Makefile-0.8.patch"



SRC_URI[md5sum] = "8455b8751083ce25c99c2840609271f5"
SRC_URI[sha256sum] = "05d1d3d9b5e33bd3642102aae10bba904e296c5c01a10854200ad4df349c8dfa"
